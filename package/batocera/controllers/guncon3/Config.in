## package/batocera/controllers/guncon3/Config.in
```kconfig
config BR2_PACKAGE_GUNCON3
	bool "guncon3"
	select BR2_PACKAGE_BATOCERA_GUN_CALIBRATOR

	help
	  guncon support
```
